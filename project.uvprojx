# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::.\ARMCompiler6.22)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: .\CMSIS;.\HAL_Library\Inc;.\HAL_Library\Inc\Legacy;.\Basic;.\BSP;.\Drivers\hardware;.\Drivers;.\Drivers\sensors;.\Drivers\ble;.\Drivers\esc;.\Drivers\buzzer;.\Drivers\oled;.\Drivers\middleWare\RTOS;.\Drivers\middleWare\RTOS\include;.\Drivers\middleWare\RTOS\CMSIS_RTOS_V2;.\Drivers\middleWare\RTOS\portable\ARM_CM7\r0p1;.\Drivers\middleWare\MAVlink\commonACFly;.\Drivers\middleWare\DroneCan;.\Drivers\middleWare\DroneCan\include;.\Drivers\middleWare\U8g2;.\Tasks;.\Communication;.\ControlSystem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Main
    ./Main/: main.cpp semihosting_stubs.c
  group Basic
    ./Basic/: basic.cpp TimeBase.cpp retarget.cpp param.cpp
  group HAL_Library
    ./HAL_Library/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
    ./HAL_Library/Inc/: stm32h7xx_hal_conf.h
  group CMSIS
    ./CMSIS/: system_stm32h7xx.c
  group Startup
    ./CMSIS/: startup_stm32h743xx.s
  group BSP
    ./BSP/: board.cpp board.hpp
  group Drivers
    ./Drivers/: drv_Main.cpp
  group Drivers\hardware
    ./Drivers/hardware/: drv_common.cpp drv_i2c.cpp drv_spi.cpp drv_uart.cpp drv_can.cpp drv_pwm.cpp
  group Drivers\sensors
    ./Drivers/sensors/: bmi08a.c bmi08g.c drv_BMI088.cpp drv_ICM20948.cpp drv_TFMini.cpp drv_US100.cpp
  group Drivers\oled
    ./Drivers/oled/: drv_oled.cpp
  group Drivers\ble
    ./Drivers/ble/: drv_KT6368A.cpp
  group Drivers\esc
    ./Drivers/esc/: drv_CubeFOC.cpp
  group Drivers\buzzer
    ./Drivers/buzzer/: drv_buzzer.cpp
  group Drivers\led
    ./Drivers/led/: drv_led.cpp
  group Drivers\middleWare\FreeRTOS
    ./Drivers/middleWare/RTOS/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Drivers/middleWare/RTOS/portable/ARM_CM7/r0p1/: port.c
    ./Drivers/middleWare/RTOS/portable/MemMang/: heap_4.c
    ./Drivers/middleWare/RTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group Drivers\middleWare\DroneCan
    ./Drivers/middleWare/DroneCan/: canard.c
    ./Drivers/middleWare/DroneCan/src/: uavcan.equipment.esc.CubeCalibCommand.c uavcan.equipment.esc.CubeIqCommand.c uavcan.equipment.esc.CubeRPMCommand.c uavcan.equipment.esc.CubeSetID.c uavcan.equipment.esc.CubeStatus.c uavcan.protocol.NodeStatus.c uavcan.protocol.GetNodeInfo_req.c uavcan.protocol.GetNodeInfo_res.c
  group Drivers\middleWare\U8g2
    ./Drivers/middleWare/U8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1315_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Communication
    ./Communication/: mavlink.cpp
  group ControlSystem
    ./ControlSystem/: MahonyAHRS.cpp LESO.cpp LQR.cpp
  group Tasks
    ./Tasks/: taskManager.cpp task_Control.cpp task_Communication.cpp task_Display.cpp
software components: CMSIS:CORE 5.6.0
